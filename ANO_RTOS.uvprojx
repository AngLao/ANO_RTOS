# Keil uVision project ANO_RTOS.uvprojx, settings and files
target ANO_RTOS (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: ANO_RTOS
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: TARGET_IS_TM4C123_RB1 PART_TM4C123GH6PM
  c include: .\TiDriver\inc;.\TiDriver\inc\driver_inc;.\TiDriver\inc\driver_hw;.\TiDriver\inc\driver_usb;.\TiDriver\inc\driver_usb\device;.\Application;.\Driver;.\Driver\SenserDriver;.\SRC\fc_general;.\SRC\fc_specific;.\Driver\SenserDriver\UWB;.\FreeRTOS;.\FreeRTOS\portable\RVDS\ARM_CM4F;.\FreeRTOS\include
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  link misc: --entry Reset_Handler
  group TiDriver
    ./TiDriver/src/: startup_TM4C123.s usb_serial_structs.c
    ./TiDriver/: driverlib.lib usblib.lib
  group SenserDriver
    ./Driver/SenserDriver/: Drv_icm20602.c Drv_UP_Flow.c Drv_ak8975.c Drv_spl06.c Drv_heating.c Drv_laser.c Ano_OF.c
    ./Driver/SenserDriver/UWB/: nlink_linktrack_tagframe0.c nlink_utils.c
  group FreeRTOS
    ./FreeRTOS/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    ./FreeRTOS/portable/RVDS/ARM_CM4F/: port.c
    ./FreeRTOS/include/: FreeRTOSConfig.h
    ./FreeRTOS/portable/MemMang/: heap_4.c
  group Driver
    ./Driver/: Drv_Bsp.c Drv_Adc.c Drv_Led.c Drv_Paramter.c Drv_RcIn.c Drv_PwmOut.c Drv_Spi.c Drv_Uart.c ring_buffer.c Drv_Timer.c watch_dog.c
  group FC_General
    ./SRC/fc_general/: Ano_FcData.c Ano_Filter.c Ano_Math.c Ano_Pid.c Ano_Imu.c Ano_Sensor_Basic.c
  group FC_Specific
    ./SRC/fc_specific/: Ano_AltCtrl.c Ano_AttCtrl.c Ano_FlightCtrl.c Ano_FlightDataCal.c Ano_LocCtrl.c Ano_MagProcess.c Ano_MotorCtrl.c
  group Application
    ./Application/: main.c Ano_Parameter.c Ano_DT.c Ano_LED.c Ano_Usb.c Ano_ProgramCtrl_User.c Ano_OF_DecoFusion.c rc_update.c uwb_task.c light_flow_task.c
    ./SRC/fc_specific/: power_management.c
  group Config
    ./SRC/fc_specific/: config.h
    ./Application/: sysconfig.h
  group Log
    ./: README.md
